# Keil uVision project TivaPong.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TivaPong
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: os.c TivaPong.c osasm.s
    ./inc/: BSP.c CortexM.c
    ./pong/controls/: joy.c
    ./pong/objects/: paddle.c ball.c
    ./pong/os/: physics.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
